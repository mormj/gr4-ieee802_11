options:
  parameters:
    author: josh
    generate_options: no_gui
    id: bench_wifi_rx
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: chan_est
  id: variable
  parameters:
    value: '0'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '2462000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: sync_length
  id: variable
  parameters:
    value: '320'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '48'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    impl: cpu
    itemsize: '0'
    nports: '1'
    showports: 'False'
  states: {state: disabled}
- name: fileio_file_source_0
  id: fileio_file_source
  parameters:
    filename: /data/data/cropcircles/wifi_synth_1500_1kpad_20MHz_10s_MCS0.fc32
    impl: cpu
    itemsize: '0'
    len: '0'
    offset: '0'
    repeat: 'False'
    showports: 'False'
  states: {}
- name: filter_moving_average_0
  id: filter_moving_average
  parameters:
    T: float
    impl: cpu
    length: window_size  + 16
    max_iter: '4096'
    scale: '1'
    showports: 'False'
    vlen: '1'
  states: {}
- name: filter_moving_average_1
  id: filter_moving_average
  parameters:
    T: complex
    impl: cpu
    length: window_size
    max_iter: '4096'
    scale: '1'
    showports: 'False'
    vlen: '1'
  states: {}
- name: ieee802_11_packetize_frame_0
  id: ieee802_11_packetize_frame
  parameters:
    algo: ieee802_11.algorithm_t.LS
    bw: samp_rate
    debug: 'False'
    freq: freq
    impl: cpu
    log: 'False'
    showports: 'False'
  states: {}
- name: ieee802_11_sync_long_0
  id: ieee802_11_sync_long
  parameters:
    debug: 'False'
    impl: cpu
    log: 'False'
    showports: 'False'
    sync_length: '320'
  states: {}
- name: ieee802_11_sync_short_0
  id: ieee802_11_sync_short
  parameters:
    debug: 'False'
    impl: cpu
    log: 'False'
    min_plateau: '2'
    showports: 'False'
    threshold: '0.56'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import time
  states: {}
- name: math_complex_to_mag_1
  id: math_complex_to_mag
  parameters:
    impl: cpu
    showports: 'False'
    vlen: '1'
  states: {}
- name: math_complex_to_mag_squared_0
  id: math_complex_to_mag_squared
  parameters:
    impl: cpu
    showports: 'False'
    vlen: '1'
  states: {}
- name: math_conjugate_0
  id: math_conjugate
  parameters:
    impl: cpu
    showports: 'False'
  states: {}
- name: math_divide_0
  id: math_divide
  parameters:
    T: float
    impl: cpu
    num_inputs: '2'
    showports: 'False'
    vlen: '1'
  states: {}
- name: math_multiply_0
  id: math_multiply
  parameters:
    T: complex
    impl: cpu
    num_inputs: '2'
    showports: 'False'
    vlen: '1'
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: fg.startt = time.time()
    section: main_after_init
  states: {}
- name: snippet_0_0
  id: snippet
  parameters:
    code: |-
      endt = time.time()
      print(f'[PROFILE_TIME]{endt-fg.startt}[PROFILE_TIME]')
    section: main_after_stop
  states: {}
- name: streamops_delay_0
  id: streamops_delay
  parameters:
    dly: '16'
    impl: cpu
    itemsize: '0'
    showports: 'False'
  states: {}
- name: streamops_delay_0_0
  id: streamops_delay
  parameters:
    dly: sync_length
    impl: cpu
    itemsize: '0'
    showports: 'False'
  states: {}
- name: streamops_stream_to_vector_0
  id: streamops_stream_to_vector
  parameters:
    impl: cpu
    itemsize: '0'
    showports: 'False'
    vlen: '64'
  states: {}

connections:
- [fileio_file_source_0, '0', math_complex_to_mag_squared_0, '0']
- [fileio_file_source_0, '0', math_multiply_0, '1']
- [fileio_file_source_0, '0', streamops_delay_0, '0']
- [filter_moving_average_0, '0', math_divide_0, '1']
- [filter_moving_average_1, '0', ieee802_11_sync_short_0, '1']
- [filter_moving_average_1, '0', math_complex_to_mag_1, '0']
- [ieee802_11_sync_long_0, '0', blocks_null_sink_0, '0']
- [ieee802_11_sync_long_0, '0', streamops_stream_to_vector_0, '0']
- [ieee802_11_sync_short_0, '0', ieee802_11_sync_long_0, '0']
- [ieee802_11_sync_short_0, '0', streamops_delay_0_0, '0']
- [math_complex_to_mag_1, '0', math_divide_0, '0']
- [math_complex_to_mag_squared_0, '0', filter_moving_average_0, '0']
- [math_conjugate_0, '0', math_multiply_0, '0']
- [math_divide_0, '0', ieee802_11_sync_short_0, '2']
- [math_multiply_0, '0', filter_moving_average_1, '0']
- [streamops_delay_0, '0', ieee802_11_sync_short_0, '0']
- [streamops_delay_0, '0', math_conjugate_0, '0']
- [streamops_delay_0_0, '0', ieee802_11_sync_long_0, '1']
- [streamops_stream_to_vector_0, '0', ieee802_11_packetize_frame_0, '0']

metadata:
  file_format: 1
